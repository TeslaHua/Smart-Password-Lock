# Keil uVision project Password.uvproj, settings and files
target Password (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Password +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HEADER
  asm include: ..\HEADER
  group MAIN
    ../MAIN/: main.c
  group SOURCE
    ../SOURCE/: Interrupt.c Keyboard.c LCD1602.c LedAndBuzzer.c At24c02.c DS1302.c
  group HEADER
    ../HEADER/: Interrupt.h Keyboard.h LCD1602.h LedAndBuzzer.h Base.h AT24C02.h DS1302.h
